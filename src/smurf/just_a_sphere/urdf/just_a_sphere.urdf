Commit message: Mls special case not colliding

File: src/smurf/just_a_sphere/urdf/just_a_sphere.urdf (robot description, URDF)
Before this commit: robot just_a_box, 1 links, 0 joints
Links:
- link sphere: mass 1.121 -> 5.121; geometry collision sphere radius=0.05; visual sphere radius=0.05
